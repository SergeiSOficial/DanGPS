<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BLE_OTA.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\DanGPS.ewp</path>
    </project>
    <batchBuild />
</workspace>
