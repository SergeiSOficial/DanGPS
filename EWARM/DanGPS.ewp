# IAR project DanGPS.ewp, settings and files
configuration DanGPS (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB10CC ST STM32WB10CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WB10xx; STM32_THREAD_SAFE_STRATEGY=3
  ICCARM.CCIncludePath2: ../Core/Inc; ../STM32_WPAN/App; ../Drivers/STM32WBxx_HAL_Driver/Inc; ../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../Utilities/lpm/tiny_lpm; ../Middlewares/ST/STM32_WPAN; ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread; ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl; ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci; ../Middlewares/ST/STM32_WPAN/utilities; ../Middlewares/ST/STM32_WPAN/ble/core; ../Middlewares/ST/STM32_WPAN/ble/core/auto; ../Middlewares/ST/STM32_WPAN/ble/core/template; ../Middlewares/ST/STM32_WPAN/ble/svc/Inc; ../Middlewares/ST/STM32_WPAN/ble/svc/Src; ../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../Utilities/sequencer; ../Middlewares/ST/STM32_WPAN/ble; ../Drivers/CMSIS/Include; ..\Core\Inc\smtc_hal; ..\Core\Inc\boards; ..\Drivers\BSP\Components\Leds; ..\Drivers\BSP\Components\lis2de12; ..\Drivers\BSP\Components\hall_effect; ..\Drivers\BSP\Components\external_supply; ..\Drivers\BSP\Components\rf_switch; ..\Drivers\BSP\Components\usr_button; ..\Core\Src\radio\lr1110_modem\src; ..\Core\Src\radio\gnss; ..\Core\Src\radio\wifi; ..\Core\Src\radio; ..\Core\Src\apps\Tracker
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DanGPS.hex
  ILINK.IlinkOutputFile: DanGPS.out
  ILINK.IlinkIcfFile: stm32wb10xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: dlib_lock_glue.c startup_stm32wb10xx_cm4.s dlib_lock_glue.c
  group Application/User/Core
    ../Core/Src/: flash_driver.c main.c gpio.c adc.c aes.c crc.c i2c.c ipcc.c iwdg.c lptim.c pka.c rf.c rng.c rtc.c spi.c app_entry.c app_debug.c hw_timerserver.c stm32_lpm_if.c standby.c usart.c stm32wbxx_it.c stm32wbxx_hal_msp.c
  group Application/User/radio
    ../Core/Src/radio/: lr1110.c lr1110_modem_hal.c
  group Application/User/smtc_hal
    ../Core/Src/smtc_hal/: smtc_hal_adc.c smtc_hal_flash.c smtc_hal_gpio.c smtc_hal_i2c.c smtc_hal_mcu.c smtc_hal_rng.c smtc_hal_rtc.c smtc_hal_spi.c smtc_hal_tmr.c smtc_hal_tmr_list.c smtc_hal_uart.c smtc_hal_watchdog.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: otas_app.c otas_stm.c app_ble.c p2p_server_app.c custom_stm.c custom_app.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_adc.c stm32wbxx_hal_adc_ex.c stm32wbxx_ll_adc.c stm32wbxx_hal_rcc.c stm32wbxx_ll_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c stm32wbxx_hal_cryp.c stm32wbxx_hal_cryp_ex.c stm32wbxx_hal_crc.c stm32wbxx_hal_crc_ex.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_ipcc.c stm32wbxx_hal_iwdg.c stm32wbxx_hal_lptim.c stm32wbxx_hal_pka.c stm32wbxx_hal_rng.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c
  group Middlewares/STM32_WPAN
    ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: tl_mbox.c hci_tl.c hci_tl_if.c shci_tl.c shci_tl_if.c
    ../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
    ../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
    ../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
    ../Middlewares/ST/STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c ble_events.c
    ../Middlewares/ST/STM32_WPAN/ble/svc/Src/: p2p_stm.c svc_ctl.c
  group Utilities
    ../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../Utilities/sequencer/: stm32_seq.c
